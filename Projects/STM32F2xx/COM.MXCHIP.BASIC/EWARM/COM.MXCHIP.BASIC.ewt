<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-F205</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.BASIC\helloworld\hello_world.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3162\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3162\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3162\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-F205</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverUART.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>utilities</name>
      <group>
        <name>jscon_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\bits.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_inttypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object_private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm3_8801.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm3_sdio.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm3_spi.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\RF driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\security\MicoCrypto.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\MFi_WAC_CM3_Release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mdns\mico_mdns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink_delegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink_wac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_factory_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M3</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M3\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M3\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MicoDriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
      <group>
        <name>STM32_USB_Host_Library</name>
        <group>
          <name>Class</name>
          <group>
            <name>MSC</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>STM32F2xx</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\EWARM\startup_stm32f2xx_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>STM32F2xx_HAL_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
              </file>
            </group>
            <group>
              <name>STM32F2xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
              </file>
            </group>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\paltform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>



<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-F205</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitHTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitPairlist.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitPairProtocol.c</name>
      <configuration>
        <name>MiCOKit-3162</name>
      </configuration>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomekitProfiles.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitSecurity_Debug.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitSecurity_Release.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\HomeKitUserInterface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.Apple.HomeKit\MICOConfigDelegate.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3162\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-3162\platform.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-F205</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-F205\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff_gen_drv.c</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\usbh_diskio.c</name>
        </file>
      </group>
      <group>
        <name>Options</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\syscall.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\unicode.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>GladmanAES</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aes_modes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aescrypt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aeskey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aestab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\gf128mul.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\SoftAP\EasyLinkSoftAP.c</name>
      </file>
    </group>
    <group>
      <name>Library</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\MICOConfig.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\MicoCrypto.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\MicoSrpServer.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\mxchipWNet_cm3_sdio.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\mxchipWNet_cm3_spi.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\tftp\tftpc.o</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\RF driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WAC\MFi_WAC_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOCli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOForceOTA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOMfgtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M3</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M3\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M3\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCODriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
      <group>
        <name>STM32_USB_Host_Library</name>
        <group>
          <name>Class</name>
          <group>
            <name>MSC</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>STM32F2xx</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\EWARM\startup_stm32f2xx_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>STM32F2xx_HAL_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
              </file>
            </group>
            <group>
              <name>STM32F2xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\stm32f2xx_conf.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\system_stm32f2xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\paltform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_bus_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F2xx\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\CheckSumUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\URLUtils.c</name>
    </file>
  </group>
</project>



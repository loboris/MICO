# Keil uVision project bootloader.uvprojx, settings and files
target MiCOKit-3088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\Bootloader\MiCOKit-3088\obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\MiCOKit-3088\bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: BOOTLOADER DEBUG NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\Board\MiCOKit-3088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\Platform\MCU\MX1101\FileSystem\inc;..\..\..\..\mico\system;..\..\..\..\libraries\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/MX1101
    ../../../../Platform/MCU/MX1101/: platform_init.c
  group Platform/MCU/MX1101/RVMDK
    ../../../../Platform/MCU/MX1101/RVMDK/: startup_mx1101_bootloader.c
  group Platform/MCU/MX1101/filesystem
    ../../../../Platform/MCU/MX1101/FileSystem/: fs.lib diskio.c partition.c presearch.c
  group Platform/MCU/MX1101/peripherals
    ../../../../Platform/MCU/MX1101/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_spi_slave.c platform_uart.c platform_watchdog.c platform_nano_second.c
  group Platform/MCU/MX1101/peripherals/Libraries
    ../../../../Platform/MCU/MX1101/peripherals/Libraries/: driver.lib
  group Board/MiCOKit-3088
    ../../../../Board/MiCOKit-3088/: platform.c platform.h
  group Board/EMW5088
    ../../../../Board/EMW5088/: platform.c platform.h platform_config.h
target EMW5088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: bootloader +hex
  AfterMake: fromelf.exe --bin  ..\..\..\..\Build\Bootloader\EMW5088\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\EMW5088\Bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER DEBUG NO_MICO_RTOS
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Bootloader;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\Board\EMW5088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\Platform\MCU\MX1101\FileSystem\inc;..\..\..\..\libraries\utilities;..\..\..\..\mico\system
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238

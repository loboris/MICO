# IAR project WiFiMCU.LUA.ewp, settings and files
configuration WiFiMCU (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\WiFiMCU; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\lua; ..\lua\exlibs; ..\spiffs; ..\..\..\..\MICO\system\command_console; ..\..\..\..\include\MicoDrivers; ..\sntp; ..\MQTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiFiMCU.LUA.bin
  ILINK.IlinkOutputFile: WiFiMCU.LUA.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\WiFiMCU\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: mico_config.h wifimcu_lua.c
  group Board/WiFiMCU
    ../../../../Board/WiFiMCU/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: Common.h Debug.h MICO.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group include/MicoDrivers
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MICODriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http-strings.h http_parse.c http_parse.h httpd.c httpd.h httpd_handle.c httpd_priv.h httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group lua
    ../lua/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lcode.c lcode.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c legc.c legc.h lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h loslib.c lparser.c lparser.h lrodefs.h lrotable.c lrotable.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltm.c ltm.h lua.c lua.h luaconf.h lualib.h lundump.c lundump.h lvm.c lvm.h lzio.c lzio.h print.c
  group lua/exlibs
    ../lua/exlibs/: adc.c bit.c DefaultFonts.c DefaultPropFont.c file.c ftp.c gpio.c i2c.c lcd.c mcu.c mqtt.c net.c oleddisp.c oledfont.h pwm.c rtc.c sensor.c spi.c tmr.c uart.c user_config.h wifi.c
  group mico/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../MICO/security/: MicoCrypto.a
  group mico/system
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c system.h system_misc.c
  group MQTT
    ../MQTT/: mico_mqtt_client_cm4_release.a MQTTClient.h
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group sntp
    ../sntp/: sntp.c sntp.h
  group spifs
    ../spiffs/: spiffs.h spiffs_cache.c spiffs_check.c spiffs_config.h spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs_nucleus.h

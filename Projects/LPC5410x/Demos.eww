<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.Apple.HomeKit\EWARM\COM.Apple.HomeKit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.BASIC\EWARM\COM.MXCHIP.BASIC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.SPP\EWARM\COM.MXCHIP.SPP.ewp</path>
  </project>

  <project>
    <path>$WS_DIR$\Cloud_RGB_LED\EWARM\Cloud_RGB_LED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Cloud_Read_Humiture\EWARM\Cloud_Read_Humiture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Cloud_RGB_Humiture\EWARM\Cloud_RGB_Humiture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MiCOKit_Enjoy\EWARM\MiCOKit_Enjoy.ewp</path>
  </project>

  <batchBuild/>
</workspace>


